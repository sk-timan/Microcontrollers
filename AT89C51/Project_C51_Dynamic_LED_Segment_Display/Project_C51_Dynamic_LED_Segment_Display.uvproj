# Keil uVision project Project_C51_Dynamic_LED_Segment_Display.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Project_C51_Dynamic_LED_Segment_Display +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Project_C51_Dynamic_LED_Segment_Display.c
